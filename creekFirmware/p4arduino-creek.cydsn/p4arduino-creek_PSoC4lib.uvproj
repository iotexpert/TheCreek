# Keil uVision project p4arduino-creek_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: p4arduino-creek_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h i2c.c i2c.h i2c_I2C.h i2c_I2C_INT.c i2c_I2C.c i2c_I2C_BOOT.c i2c_I2C_SLAVE.c i2c_PM.c i2c_BOOT.c i2c_PINS.h i2c_I2C_PVT.h i2c_PVT.h adc.c adc.h adc_PM.c adc_INT.c highside.c highside.h highside_aliases.h i2c_SCB_IRQ.c i2c_SCB_IRQ.h i2c_SCBCLK.c i2c_SCBCLK.h i2c_scl.c i2c_scl.h i2c_scl_aliases.h i2c_sda.c i2c_sda.h i2c_sda_aliases.h adc_intClock.c adc_intClock.h adc_IRQ.c adc_IRQ.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h Clock_1.c Clock_1.h
target Release (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: as above
  output: p4arduino-creek_PSoC4lib (library)
